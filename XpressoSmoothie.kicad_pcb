# Repository TopherMan/XpressoSmoothie

File README.md:

Overview
========
This is a plan to make a RepRap electronics solution capable of running the Smoothie firmware. The board will be built around the LPCXpresso 1769, with a more modular design in the spirit of RAMPS. More information about the RepRap project can be found at http://reprap.org, and more information about Smoothie can be found at http://smoothieware.org.

Features
========
* 120 MHz ARM Cortex-M3 processor, chosen to run the highly efficent and modular Smoothie firmware (https://github.com/arthurwolf/Smoothie).
* Can be powered by 12V or 24V.
* 5 Axes, using Pololu A4988-style stepper drivers.
* 4 Power output MOSFETs, two with automotive blade-style fuses for bed and heater over-current protection.
* 6 endstops and 3 thermistors.
* Integrated microSD reader.
* Pins broken out for SPI, I2C, GPIO, and on-board Ethernet chip for future expansion.
* Due to the modular nature of Smoothie, the board should also work with mills, laser cutters, and any future modules.

Current Status
==============
Revision 0 boards had issues due to pins being assigned to ports hard-coded to other purposes in Smoothie. Revision 1 had issues due to pin assignment changes in the Smoothie firmware. Revision 2 is close to complete, with pinout verification needed.

Opto Endstops
=============
Noobman is finalizing designs for a small seperate opto board.

Bill of Materials -- NOTE: may need to be updated
=================
Two bill of material files are included. BOM.ods lists the individual components and their corresponding Digikey part numbers. BOM_Digikey.xls is formatted for uploading directly to Digikey. There are three columns available, one for the complete range of parts, one for everything except opto circuitry (though the difference is only 6 resistors), and one without opto circuitry or headers, so you can use big cheap strips of breakaway headers.

To Use
======
Assembly instructions will be made with the alpha board.
Flashing the bootloader and getting Smoothie on the LPCXpresso can be found at http://smoothieware.org/smoothie-on-a-breadboard.

More Information
================
Wiki page at http://reprap.org/wiki/Xpresso_Smoothie.

Authors
=======
TopherMan (Chris George) -- Initial design idea and basic layout, as well as testing and assembly.
Noobman -- Significant input on design, and completed nearly all routing.
Bobc -- kicad libraries are borrowed from his repo here: https://github.com/bobc/bobc_hardware Additionally, blade fuse usage based on his design for RAMPS_FD

## KiCad design XpressoSmoothie.kicad_pcb

Parts:
C1, C2, C3, C4, C12, C13, C14: 100u
C5, C7, C23, C24: 1u/50v
C6, C8: 1u/50v; SM1206
C9, C10, C11: 10u
C15, C16, C17, C18, C19, C20, C21: 220n
C22: 1u; SM1206
D1, D2, D7, D8: 1N4007
D3: POWER_1
D4: POWER_2
D5: POWER_3
D6: POWER_4
D9: LED4
D11: V_GATES
D12: 3V3
D13: LED2
D14: LED3
D15: LED1
F1, F2: FUSE
Hole1, Hole2, Hole3, Hole4: CONN_1
J1, J2, J7, J8, J12, J15, J27, J29, J30: HEADER_4
J3, J16, J17, J18, J23, J24, J25: HEADER_3
J4, J5, J9, J10, J14: HEADER_3X2
J6: LPCXPRESSO_1769_HEADER
J11: Pwr_in
J13: HEADER_6
J19, J20, J21, J22: HEADER_2
J26: USB
J28: MICROSD-MOLEX
M1: LOGO_OSHW; OSHW_logo_large
M2: LOGO_OSHW; OSHW_logo_10
Q1, Q2, Q3, Q4: IRLB 8743
R1, R2, R5, R6, R10, R11, R12, R13: 4k7
R3, R4, R8, R9, R14: 1k
R7, R15, R16, R17, R20, R22, R24, R25, R26, R30: 100
R18, R19, R21, R23: 1k8
R27, R28, R31, R32: 10k
R29: 680
SW1, SW2, SW3: SW_PUSH
Th0, Th1, Th2: CONN_2
U1, U2, U3, U4, U5: POLOLU_A4988
U7: LM7809CT; TO-220
U8, U9, U10, U11: TC4422A
U12: LM1117-3.3; TO-220

Connections:
*32_RD-: J6.32, J27.4
*33_RD+: J6.33, J27.3
*34_TD-: J6.34, J27.2
*35_TD+: J6.35, J27.1
*Bootloader: J6.51, SW3.1
*CS: J6.8, J28.2
*CS0: J6.14, J30.4
*LED1: J6.101, R20.2
*LED2: J6.102, R26.2
*LED3: J6.103, R17.2
*LED4: J6.104, R22.2
*MISO: J6.6, J28.7
*MISO0: J6.12, J30.2
*MOSI: J6.5, J28.3
*MOSI0: J6.11, J30.1
*PLAY/PAUSE: J6.53, SW2.1
*PLAY_LED: J6.115
*RESET: J6.4, SW1.1
*RX: J6.21, J29.4
*SCK: J6.7, J28.5
*SCK0: J6.13, J30.3
*SCL0: J6.26, J15.4
*SDA0: J6.25, J15.3
*THERM0: C11.1, J6.15, R12.1, Th0.1
*THERM1: C10.1, J6.16, R11.1, Th1.1
*THERM2: C9.1, J6.17, R10.1, Th2.1
*TX: J6.22, J29.3
*USB-D+: J6.37, J26.3 (D+)
*USB-D-: J6.36, J26.2 (D-)
*USB_SOFT_CONNECT: J6.119
+3.3VP: C14.1, C16.1, C22.1, J6.28, J15.1, J16.1, J17.1, J18.1, J23.1, J24.1, J25.1, J28.4, J29.2, R3.2, R4.2, R7.1, R8.2, R9.2, R10.2, R11.2, R12.2, R14.2, R15.1, R16.1, R24.1, R25.1, R30.2, U12.2 (OUT)
+5V: J3.3, J13.1, J26.1 (Vbus)
/THERM3: J6.18
A-DIR: J6.38, U5.16 (DIR)
A-EN: J6.39, R13.2, U5.9 (EN)
A-STEP: J6.42, U5.15 (STEP)
B-DIR: J6.117, U1.16 (DIR)
B-EN: J6.116, R1.2, U1.9 (EN)
B-STEP: J6.50, U1.15 (STEP)
BUZZ: J6.20, J13.5
CLICK: J6.19, J13.3
ENC_A: J6.105, J13.6
ENC_B: J6.106, J13.4
GND: C1.2, C2.2, C3.2, C4.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, D9.2 (K), D12.2 (K), D13.2 (K), D14.2 (K), D15.2 (K), J6.1, J6.54, J11.3, J15.2, J16.2, J17.2, J18.2, J23.2, J24.2, J25.2, J26.4 (GND), J26.5 (Shield_1), J26.6 (Shield_2), J28.6, J28.GND, J28.POL, J29.1, R27.1, R28.1, R31.1, R32.1, SW1.2, SW2.2, SW3.2, Th0.2 (PM), Th1.2 (PM), Th2.2 (PM), U1.1 (GND), U1.7 (GND), U2.1 (GND), U2.7 (GND), U3.1 (GND), U3.7 (GND), U4.1 (GND), U4.7 (GND), U5.1 (GND), U5.7 (GND), U7.2 (GND), U12.1 (ADJ)
GNDPWR: C5.2, C6.2, C7.2, C23.2, C24.2, J11.2, Q1.S, Q2.S, Q3.S, Q4.S, R29.1, U8.4 (GND), U8.5 (GND), U9.4 (GND), U9.5 (GND), U10.4 (GND), U10.5 (GND), U11.4 (GND), U11.5 (GND)
unnamed: J10.5, U4.12 (MS3)
unnamed: J10.1, U4.10 (MS1)
unnamed: J8.4, U4.6 (2B)
unnamed: J8.1, U4.3 (IB)
unnamed: J8.2, U4.4 (1A)
unnamed: J8.3, U4.5 (2A)
unnamed: J10.3, U4.11 (MS2)
unnamed: J14.2, J14.4, J14.6, R13.1, R14.1, U5.13 (RST), U5.14 (SLP)
unnamed: J10.2, J10.4, J10.6, R6.1, R9.1, U4.13 (RST), U4.14 (SLP)
unnamed: J14.5, U5.12 (MS3)
unnamed: J14.1, U5.10 (MS1)
unnamed: J12.4, U5.6 (2B)
unnamed: J12.1, U5.3 (IB)
unnamed: J12.2, U5.4 (1A)
unnamed: J12.3, U5.5 (2A)
unnamed: J14.3, U5.11 (MS2)
unnamed: D2.1 (A), D4.2 (K), J20.1, Q2.D
unnamed: Q2.G, U9.6 (OUT), U9.7 (OUT)
unnamed: D4.1 (A), R21.2
unnamed: J5.2, J5.4, J5.6, R2.1, R4.1, U2.13 (RST), U2.14 (SLP)
unnamed: D1.1 (A), D3.2 (K), J19.1, Q1.D
unnamed: Q1.G, U8.6 (OUT), U8.7 (OUT)
unnamed: D3.1 (A), R19.2
unnamed: J9.5, U3.12 (MS3)
unnamed: J9.1, U3.10 (MS1)
unnamed: J7.4, U3.6 (2B)
unnamed: J7.1, U3.3 (IB)
unnamed: J7.2, U3.4 (1A)
unnamed: J7.3, U3.5 (2A)
unnamed: J9.3, U3.11 (MS2)
unnamed: J9.2, J9.4, J9.6, R5.1, R8.1, U3.13 (RST), U3.14 (SLP)
unnamed: J5.5, U2.12 (MS3)
unnamed: J5.1, U2.10 (MS1)
unnamed: J2.4, U2.6 (2B)
unnamed: J2.1, U2.3 (IB)
unnamed: J2.2, U2.4 (1A)
unnamed: J2.3, U2.5 (2A)
unnamed: J5.3, U2.11 (MS2)
unnamed: D9.1 (A), R22.1
unnamed: D14.1 (A), R17.1
unnamed: D13.1 (A), R26.1
unnamed: D15.1 (A), R20.1
unnamed: J3.2, U12.3 (IN)
unnamed: F1.2, J19.2
unnamed: F2.2, J20.2
unnamed: D11.2 (K), R29.2
unnamed: D6.2 (K), D7.1 (A), J22.1, Q4.D
unnamed: Q4.G, U10.6 (OUT), U10.7 (OUT)
unnamed: D6.1 (A), R18.2
unnamed: D5.2 (K), D8.1 (A), J21.1, Q3.D
unnamed: Q3.G, U11.6 (OUT), U11.7 (OUT)
unnamed: D5.1 (A), R23.2
unnamed: D12.1 (A), R30.1
unnamed: J4.5, U1.12 (MS3)
unnamed: J4.1, U1.10 (MS1)
unnamed: J1.4, U1.6 (2B)
unnamed: J1.1, U1.3 (IB)
unnamed: J1.2, U1.4 (1A)
unnamed: J1.3, U1.5 (2A)
unnamed: J4.3, U1.11 (MS2)
unnamed: J4.2, J4.4, J4.6, R1.1, R3.1, U1.13 (RST), U1.14 (SLP)
unnamed: R15.2, U2.2 (VDD)
unnamed: R16.2, U3.2 (VDD)
unnamed: R24.2, U4.2 (VDD)
unnamed: R25.2, U5.2 (VDD)
unnamed: R7.2, U1.2 (VDD)
PANEL_KILL: J6.52, J13.2
POWER1: J6.49, R27.2, U8.2 (IN)
POWER2: J6.48, R28.2, U9.2 (IN)
POWER3: J6.47, R31.2, U11.2 (IN)
POWER4: J6.113, R32.2, U10.2 (IN)
PS-ON: J6.46
SD_card_detect: J28.DET
Vgates: C5.1, C7.1, C13.1, C15.1, C23.1, C24.1, D11.1 (A), J3.1, U7.3 (OUT), U8.1 (VDD), U8.8 (VDD), U9.1 (VDD), U9.8 (VDD), U10.1 (VDD), U10.8 (VDD), U11.1 (VDD), U11.8 (VDD)
Vin_Hi_curr: C6.1, D1.2 (K), D2.2 (K), D7.2 (K), D8.2 (K), F1.1, F2.1, J11.1, J21.2, J22.2, R18.1, R19.1, R21.1, R23.1
Vin_rmot: C1.1, C2.1, C3.1, C4.1, C8.1, C12.1, C17.1, C18.1, C19.1, C20.1, C21.1, J11.4, U1.8 (VMOT), U2.8 (VMOT), U3.8 (VMOT), U4.8 (VMOT), U5.8 (VMOT), U7.1 (IN)
X-DIR: J6.118, U2.16 (DIR)
X-EN: J6.27, R2.2, U2.9 (EN)
X-STEP: J6.45, U2.15 (STEP)
XMAX: J6.108, J24.3
XMIN: J6.107, J17.3
Y-DIR: J6.23, U3.16 (DIR)
Y-EN: J6.24, R5.2, U3.9 (EN)
Y-STEP: J6.44, U3.15 (STEP)
YMAX: J6.114, J25.3
YMIN: J6.109, J18.3
Z-DIR: J6.40, U4.16 (DIR)
Z-EN: J6.41, R6.2, U4.9 (EN)
Z-STEP: J6.43, U4.15 (STEP)
ZMAX: J6.110, J23.3
ZMIN: J6.111, J16.3

Notes on the sheet:
POWER
MOSFETS
Output connectors are V+ and GND. Q1 is bed mosfet to keep high current trace short. Solder a thick copper wire from input to Q1 and back.
Enstops and Thermistors
STEPPER DRIVERS
SD card
I2C
Expansion
USB
Miscellaneous
Pololu drivers or compatible footprint: http://www.pololu.com/catalog/category/120
MOS drivers TC4452 (SOIC-8-Narrow) or TC4422A (SOIC-8-WIDE), check and adjust pcb footprint if needed.
Components: all smd ceramic caps dielectric X5R or X7R or better, leds: 20mA. Mosfet output connectors are V+ and GND. Q1 is bed mosfet to keep high current trace short. Solder a thick copper wire from input to Q1 and back (both on V+ and gnd) to help with the high current. For DIY purposes increas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
LPCXpresso 1769
Power in: 12V to 28V The two input connector voltages must come from same psu (same gnd), though may have different values.
Vin_Hi_curr does not have led indicator
Regulators have different pin numbering If Vin_r is 12V then Vgates are 12V-2Vdroput= 10V
Ethernet
Serial
*NOTE: Labels starting with * are hard-coded to a specific use and cannot be reassigned.
NOTE: Pins 9 and 10 are hard-coded in Smoothie for I2C communication with current-sense chips.
SPI
PANEL
LED1 init done, LED2 main loop LED3 idle loop, LED4 SD okay

Board: 2 copper layers, 99.7 x 99.7 mm, 129 parts (1 on the bottom side), 131 nets.

## KiCad design optoendstop/XpressoSmoothieOpto.kicad_pcb

File optoendstop/README.md:

Overview
========
Optoendstops for LPCXpressoSmoothie

Board: 2 copper layers, 99.7 x 99.7 mm, 13 parts (0 on the bottom side), 6 nets.

Parts:
D1: green; LED-0805-3MM
Hole1, Hole2, Hole3, Hole4: CONN_1; 1pin
IC1: TCST1103; TCST1103-2103
IC11: TCST1103; TCRT1000
J1: HEADER_4; PIN_ARRAY_4x1
M2: LOGO_OSHW; OSHW_logo_2
Q1: BS108D; sot23-to92
R1: 150; SM1206
RL_diode1: 68; SM1206
Rp_rcv1: 1k5; SM1206

Connections:
3.3V: J1.4, R1.2, RL_diode1.2, Rp_rcv1.1
GND: IC1.E/D, IC1.K/E, IC11.E/D, IC11.K/E, J1.2, Q1.S
unnamed: D1.1, R1.1
unnamed: D1.2, Q1.D
unnamed: IC1.A/+, IC11.A/+, RL_diode1.1
Signal1: IC1.C/+, IC11.C/+, J1.1, Q1.G, Rp_rcv1.2

## Commit log

2013-05-12 Initial commit. Schematic only missing mosfets.
2013-05-12 Added power plug and first mosfet.
2013-05-12 Finish wiring labels.
2013-05-12 Generate Netlist
2013-05-13 Switch around pins and add pins for UART. Finish most of netlist.
2013-05-13 Added README
2013-05-13 Minor tag issues.
2013-05-13 Finished all footprints except polyfuses.
2013-05-14 Added fuse footprint, taken from bobc_hardware/RAMPS_FD
2013-05-14 Add screw terminal .mod file, plus tons of fixes/layout changes.
2013-05-14 Working on layout. Needed to move from 5cmx10cm to 10cmx10cm.
2013-05-14 Everything placed approximately.
2013-05-14 Switch out header for proper SD card connector.
2013-05-14 Begun laying traces.
2013-05-15 Bunch of tracks made. A few minor label issues fixed.
2013-05-15 Finished most of the tracks. Need to add some stuff.
2013-05-15 Add LM1117 and jumper to power from 12V or from USB.
2013-05-15 Fixed stupid labelling error.
2013-05-15 Finished layout attempt 1. Will probably add I2C header in a bit.
2013-05-15 D'oh, made everything fit within 10cmx10cm envelope. Added some labels.
2013-05-16 Start making changes suggested by NoobMan.
2013-05-16 Fixed FETs so that they're non-inverting.
2013-05-16 Added I2C header.
2013-05-16 Fixed up netlist and footprints, being layout attempt 2.
2013-05-16 Started new layout. Let's see how this goes...
2013-05-16 Getting close to something that works.
2013-05-16 Working on layout. Mosfets looks pretty okay.
2013-05-17 Another layout complete.
2013-05-17 Bunch of changes. Trying a cleaner layout.
2013-05-18 Trying with the LPCXpresso turned the other way. Maybe this will work a bit smoother.
2013-05-18 Fixed the pinout to something that makes sense for the new orientation. Also, going to bed.
2013-05-18 preliminary schematic structure, annotation changes
    organizing, few additions and deletions, annotation changed
    added notes of few things to be sorted later
2013-05-18 gitattributes
2013-05-18 Change around voltage select for powering the board. Fixes #2.
2013-05-18 Updated footprints, netlist, and got board ready for placing parts. I think I need to update the SD card reader footprint; it's missing pad 10 and is based on 3M's design which isn't manufactured any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
2013-05-18 Added footprint for transflash microsd card reader.
2013-05-18 Updated MicroSD holder.
2013-05-19 brd file kicad_pcb, layout attempt
    changed pcb file from brd to *.kicad_pcb extension, few schematic
    changes and attempted a layout
2013-05-19 test - dummy
    dummy change for check purposes
2013-05-19 stiching up routes for module
    routes that need to be checked from blocks to module
2013-05-19 pin allocation sketch
    pin allocation sketch for checking
2013-05-19 pin allocation variant
    pin allocation variant, to be checked
2013-05-19 pin allocation
    pin allocation, needs to be checked
    and ethernet header
2013-05-19 step line moved from pin24 (p0.22)
    and changed pin24 (p0.22) to enable xy
2013-05-20 Finished connecting the dots.
2013-05-20 Missed a connection on Q1, and moved C8 so it doesn't overlab C1.
2013-05-20 Changed the order of the steppers so that B is off on its own instead of X.
2013-05-20 Missed a connection.
2013-05-21 pin allocation, drivers again
    needed pin changes to x and y can have same enable while being in same
    line for wiring, driver changed, polished schematic, board still needs
    small tweaks
2013-05-21 footprint text correction
2013-05-21 spaced the 4 pololu on top
    spaced the 4 pololu on top
2013-05-21 General cleanup.
2013-05-21 Update Readme and License file.
2013-05-21 Improved README
2013-05-21 Added example Smoothie config file.
2013-05-21 Adjusted Smoothie config file. Lines that need to be set by user are preceeded by ##.
2013-05-21 Updated gitigonre.
2013-05-21 Added Open Source Hardware logos on front and back, and added board name and rev number to front.
2013-05-21 Begin label cleanup.
2013-05-21 Labels and values cleaned. All the important stuff is clearly labeled, and all small labels and values are visible and non-overlapping.
2013-05-23 pin24 allocation
    pin 24 re-allocation to enable xy
2013-05-23 Fixed the logos so that they were added the proper way, with a placeholder in the schematic. Fixes #6.
2013-05-24 Hid a bunch of labels to un-clutter the silkscreen.
2013-05-24 Hid more labels, added some in so that everything is clearly marked and there are no overlaps.
2013-05-24 Adjusted clearance for pads/vias/tracks to 0.2 mm. Still within allowed tolerances for Seeedstudio (and probably other fab houses), but stops the DRC from complaining.
2013-05-27 minor xy-en reroute
    minor xy-en reroute
2013-05-28 Created BOM and begun slogging through DigiKey.
2013-05-28 Got Digikey numbers for everything except resistors. Need to verify values first.
2013-05-28 Updated resistor values, calculated based on http://led.linear1.org/1led.wiz. Closes #9.
2013-05-28 Adjusted BOM and added .xls file formatted to upload straight to Digikey.
2013-05-29 Switched over to minimal Molex SD card connector.
2013-05-29 Fixed resistor values.
2013-05-29 Fixed Molex MicroSD holder. Closes #8.
2013-05-29 shifted uSD
    shifted uSD holder more to the edge, changed resistor values (yet again)
2013-05-29 updated values
    updated led resistors more like you wanted
2013-05-29 Renamed BOM files for clarity.
2013-05-29 Updated BOM to reflect changes in resistor values, SD reader, etc.
2013-05-29 Fixed a few minor errors in BOM, updated BOM_Digikey with proper numbers, as well as descriptions. Closes #10.
2013-05-30 mbed_compat
    work dir for mbed compat and bkp.zip for current stage
2013-05-30 Very minor cleanup to prep for fabrication.
2013-05-30 libpath_relative
    no visual changes
2013-05-30 A few more minor adjustments for fabrication.
2013-05-30 Updated README.
2013-05-30 pin alloc mbed compat
    pin allocation for mbed compatibility
2013-05-30 expansion 4gnd
    plus 1 gnd pin for expansion
2013-05-30 mos4 pwm fix
    mos 4 pwm
2013-05-30 Added jumpers for powering LPCXPresso or mbed.
2013-05-31 Attempting to add jumpers for mbed-compatible board.
2013-05-31 Finished setting up jumpers and laying power traces for mbed-compatible.
2013-05-31 Oh, duh. Since the VIN pin isn't connected to anything on the Xpresso, it doesn't need a jumper. I can just put 5V on that pin for the mbed and that Xpresso won't be hurt.
2013-05-31 Fixed the 5V trace on the board.
2013-05-31 Make two config files. One for LPCXpresso, one for mbed.
2013-05-31 Update config for xpresso.
2013-05-31 Update config for mbed.
2013-05-31 latest changes
    latest changes
2013-05-31 endstops jumper
    endstops jumper
2013-05-31 endstops 4 pins
    endstops 4 pins, removed jumper selector
2013-06-01 directories_rearrange
2013-06-01 curr_release
2013-06-01 endstops_mod
2013-06-01 some labels
2013-06-01 optos
2013-06-01 opto_sch
2013-06-01 Minor jumper change. Don't need to power Vbat.
2013-06-01 Removed extra jumper from board.
2013-06-01 Fixed up jumpers. Removed an extra, removed sd_detect so that x and y enable are seperate, and added one so they are joined together. Closes #14.
2013-06-01 Thinned board edge lines.
2013-06-02 Reset to using SD detect.
2013-06-02 Reverted back to using SD detect. Added jumper to connect/disconnect 5V line to USB Vbus. I think this finally means we're compatible with the mbed, so closing #11 again.
2013-06-02 Fixed up fuses (which were hanging slightly over the edge) and thinned edge graphics for clarity.
2013-06-02 opto-dir
    opto-dir
2013-06-02 Moved USB so that PCB edge line lines up with the edge of the PCB. Also removed silkscreen lines that hung over the edge. Closes #15.
2013-06-02 Moved some traces and text so that there is a minimum of 10 mil clearnace between any traces or pads and the pcb edge. Closes #16.
2013-06-02 Spruced up the labels a bit.
2013-06-02 D'oh, cut the 3.3v line to card reader. Fixed.
2013-06-02 Switched around endstop names so they're in order going top to bottom.
2013-06-02 Updated README to mention mbed compatiblity.
2013-06-02 Actually, mbed may not be open source. Removed until I can confirm it.
2013-06-02 First set of gerbers created. Barring major catastrophe, they will be sent off tomorrow for fabrication.
2013-06-02 Adjusted config files and README to reflect feature set. Added note about Opto endstops. Maybe add detailed instructions on optos to the optoendstop subdir? Tentatively closing #18.
2013-06-03 fill zones
    added fill
2013-06-03 fillzone
2013-06-03 opto_lib_and_mod
2013-06-03 Updated BOM to reflect all recent changes. Now up-to-date with the board.
2013-06-03 Updated BOM_Digikey, and added no opto and no header options for ease of use.
2013-06-03 Added note about BOM to README.
2013-06-03 Fixed up some formatting in README, and added section about setting jumpers.
2013-06-03 Whoops, forgot jumpers on BOM. Added them in. Close #17.
2013-06-03 Updated BOM b.c. jumpers must be ordered in multiples of 10.
2013-06-03 oe_mod
    oe_mod
2013-06-04 optoendstops
    optoendstops
2013-06-04 optod-rem-jumper
    removed jumper
2013-06-04 oe_clearance
    optoendstops clearance check
2013-06-04 General cleanup of backups. Gerbers in _current_release did not match the Rev0 zip files. Additionally, the Rev0 archive had out of date README and BOMs.
2013-06-05 oe
    oe
2013-06-20 Switch micro USB Digikey part number in BOM. Original one was upside-down from what we needed. Closes #22.
2013-06-20 Change 11A fuse footprint to MF-R500 (5A footprint) since that's what fits. Closes #21
2013-06-20 Adjusted README to reflect current status.
2013-06-27 Begin re-routing bad pin assignments.
2013-06-27 Marked I2C1 as NC since it's hard-coded to read digipots.
2013-07-09 Pins should be laid out to work properly now for LPCXpresso.
2013-07-09 All jumpers added to schematic, so it should all be set for mbed and for LPCXpresso. Time to start routing.
2013-07-09 Components assigned.
2013-07-10 Begin routing.
2013-07-10 Finished routing new pin assignments and jumpers and stuff.
2013-07-10 Added notes on silkscreen for jumpers. After one or two additional checks, I'll officially call it revision 1.
2013-07-10 Updated README and noted that configs are currently incorrect.
2013-07-10 Minor silkscreen changes.
2013-07-11 Few more silkscreen changes. Closes #20.
2013-07-13 Updated schematic so that pins hard-coded to a specific purpose have a label beginning with * as recommended in #20.
2013-07-13 Update config.xpresso.
2013-07-13 update config.mbed.
2013-07-13 Realized it makes more sense to tie XYZ enables together for mbed instead of XYA. An mbed user would be able to do filament changes by jogging the head to a new position, disabling A, changing filame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
2013-07-13 Updated BOM to include new changes.
2013-07-13 Updated README with jumper info.
2013-11-29 Reassigned pins based on http://smoothieware.org/lpc1769-pin-usage.
2013-11-29 Remove mbed jumpers, add expansion ports, add LEDs 1 - 4
2013-11-29 Added note about leds.
2013-11-29 Whoopsie
2013-11-29 Get components correct.
2013-11-29 Start messing around with layout.
2013-12-02 Replace polyfuses with auto blade fuses, imitating RAMPS-FD
2013-12-02 Get things sorta arranged.
2013-12-03 Bunch of routing. A few pin reassignments, make sure to adjust example config file.
2013-12-03 Routing nearly done (for now).
2013-12-03 Remove LED for vin_rmot.
2013-12-03 Layout seems complete.
2013-12-03 Add fill for top layer, move giant OSHW logo to center.
2013-12-03 Clean up silkscreen, fix a few whoopsies.
2013-12-03 Remove all references to mbed compatibility.
2013-12-03 Mention bobc's libraries.
2013-12-03 Remove archive folders -- git handles old revisions properly
2013-12-03 Update config to match new pin assignments.
2014-04-08 Added pullups for the gate mosfets per Noobman's suggestion.
